# Keil uVision project project.uvprojx, settings and files
target project (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ESEL ELITTLE
  output: project +hex
  AfterMake: .\utils\genbinary.bat
  group Drivers\system
    ../../../Drivers/system/: printf-stdarg.c startup_cm4.S system_cm4.c
  group Drivers\peripheral\src
    ../../../Drivers/peripheral/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group Drivers\sensor
    ../../../Drivers/sensor/: bsp.c flash_eraseprogram.c gpio_exti.c I2C_A.c ds18b20.c I2C_sensor.c weight.c tfsensor.c ult.c pwm.c TMP117_I2C.c sht3x.c sht40.c
  group user
    ./src/: main.c tremo_it.c lora_app.c command.c
  group Middlewares\LoRa\driver
    ../../../Middlewares/LoRa/driver/: rtc-board.c sx1262-board.c utilities.c
  group Middlewares\LoRa\radio
    ../../../Middlewares/LoRa/radio/sx126x/: radio.c sx126x.c
  group Middlewares\LoRa\system
    ../../../Middlewares/LoRa/system/: delay.c timer.c
    ../../../Middlewares/LoRa/system/Crypto/: aes.c cmac.c
  group Middlewares/Lora/Mac/region
    ../../../Middlewares/LoRa/LoRaMac-node/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionKZ865.c RegionMA869.c RegionRU864.c RegionUS915.c
  group Middlewares/Lora/Mac
    ../../../Middlewares/LoRa/LoRaMac-node/: LoRaMac.c LoRaMacCrypto.c
    ../../../Middlewares/LoRa/Core/: lora-test.c
